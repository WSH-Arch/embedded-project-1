# Keil uVision project Smart_AGR.uvprojx, settings and files
target smart_AGR (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Smart_AGR +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,
  c include: ..\USER;..\FWLIB\inc;..\CORE;..\SYSTEM\SYSTEM\delay;..\SYSTEM\SYSTEM\sys
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_exti.c stm32f4xx_tim.c stm32f4xx_adc.c stm32f4xx_usart.c stm32f4xx_i2c.c stm32f4xx_spi.c stm32f4xx_dma.c
  group HARDWARE
    ../HARDWARE/: LED.c BEEP.c KEY.c SYSTICK.c TIMER.c interrupt.c pwm.c my_usart.c DTH11.c iic.c iic_at24c02.c iic_ssd1306_oled.c myadc_devce.c SPI.c SPI_W25Q64.c dma.c
  group SYSTEM
    ../SYSTEM/SYSTEM/delay/: delay.c
    ../SYSTEM/SYSTEM/sys/: sys.c
  group USER
    ./: system_stm32f4xx.c user.c
